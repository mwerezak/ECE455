# Keil uVision project bursty.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: bursty
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./: startup_LPC17xx.s main.c
  group mcb1700_ece
    ../mcb1700_ece/: GLCD.h GLCD_SPI_LPC1700.c system_LPC17xx.c
  group common
    ../common/: led.c pushbutton.c timer.c debouncetest.c debounce.c
